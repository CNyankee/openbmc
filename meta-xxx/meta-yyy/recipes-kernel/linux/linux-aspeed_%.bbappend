FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-yyy-xxx-add_yyy_platform_dts-add_eeprom_fru.patch"

